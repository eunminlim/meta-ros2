# Copyright (c) 2015-2017 LG Electronics, Inc.
AUTHOR = "Valery Volgutov <valery.volgutov@lge.com>"
EXTENDPRAUTO_append = "pro0"

PACKAGECONFIG_append = " pixmap"
